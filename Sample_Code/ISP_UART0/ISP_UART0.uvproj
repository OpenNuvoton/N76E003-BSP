# Keil uVision project ISP_UART0.uvproj, settings and files
target UART_mode_2 (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: ISP_UART0 +hex
  AfterMake: ..\..\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\..\Include;
  group Source
    ./Source/: main.c UART0_transfer.c
  group Startup
    ../../Startup/: STARTUP.A51
