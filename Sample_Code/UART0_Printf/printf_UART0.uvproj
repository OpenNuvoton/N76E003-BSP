# Keil uVision project printf_UART0.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Printf_UART1 +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: PUTCHAR.C Print_UART0.C
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
